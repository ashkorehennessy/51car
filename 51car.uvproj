# Keil uVision project 51car.uvproj, settings and files
target Target 1 (MCS-51)
  device: STC89C52RC Series STC
  cpu: IRAM(0-0xFF) XRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(45000000) MODP2
  output: 51car
  c flags: Optimize=8 SizeSpeed=1
  c define: STC89
  c include: .\STC89_Lib\inc
  group Source Group 1
    ./: main.c
    ./STC89_Lib/src/: exti.c nvic.c system.c timer.c uart.c MFRC522.c
    ./STC89_Lib/template/: config.h
